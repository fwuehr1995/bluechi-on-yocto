require bluechi_common.inc

SRC_URI = "gitsm://github.com/eclipse-bluechi/bluechi.git;protocol=https;branch=main"
SRCREV = "eef29dd600425c438bb35f36b22f5c268542ebcb"
