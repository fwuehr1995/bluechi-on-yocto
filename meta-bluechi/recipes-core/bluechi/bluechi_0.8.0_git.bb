require bluechi_common.inc

SRC_URI = "gitsm://github.com/eclipse-bluechi/bluechi.git;protocol=https;branch=main"
SRCREV = "1fc774161570db0d115543b96c549f7dd9deb20d"
