require bluechi_common.inc

SRC_URI = "gitsm://github.com/eclipse-bluechi/bluechi.git;protocol=https;branch=main"
SRCREV = "0e202a8afa051812275b32318010626d8e10caca"
